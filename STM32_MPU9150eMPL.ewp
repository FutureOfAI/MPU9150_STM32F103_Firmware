# IAR project STM32_MPU9150eMPL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; MPU9150
  ICCARM.CCIncludePath2: .; ..\STM32_MPU9150eMPL; ..\STM32_MPU9150eMPL\Libraries\CMSIS\Include; ..\STM32_MPU9150eMPL\Libraries\CMSIS\Device\ST\STM32F10x\Source\Templates\iar; ..\STM32_MPU9150eMPL\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\STM32_MPU9150eMPL\Libraries\STM32_USB-FS-Device_Driver\inc; ..\STM32_MPU9150eMPL\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\STM32_MPU9150eMPL\Libraries\STM32_CPAL_Driver\inc; ..\STM32_MPU9150eMPL\Libraries\STM32_CPAL_Driver\devices\STM32F10x; ..\STM32_MPU9150eMPL\Application\inc; ..\STM32_MPU9150eMPL\eMPL; ..\STM32_MPU9150eMPL\VirtualCOMport\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32_MPU9150eMPL.hex
  ILINK.IlinkOutputFile: STM32_MPU9150eMPL.out
  ILINK.IlinkIcfFile: STM32_MPU9150eMPL.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group (top)
    ./: README.txt
  group Application
    ./: main.c
    Application/src/: mpu9150_interrupts.c stm32_CPAL_mpu9150.c stm32_it.c utils.c
  group eMPL
    eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group STM32F10x/CMSIS
    Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/iar/: startup_stm32f10x_md.s
    Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/: system_stm32f10x.c
  group STM32F10x/CPAL_HAL
    Libraries/STM32_CPAL_Driver/devices/stm32f10x/: cpal_i2c_hal_stm32f10x.c
  group STM32F10x/STM32_CPAL_Driver
    Libraries/STM32_CPAL_Driver/src/: cpal_hal.c cpal_i2c.c cpal_usercallback_template.c
  group STM32F10x/STM32F10x_StdPeriph_Driver
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STM32F10x/USB-FS-Device-Driver
    Libraries/STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group VirtualCOMport
    VirtualCOMport/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
